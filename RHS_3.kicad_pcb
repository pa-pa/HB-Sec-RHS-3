# Repository pa-pa/HB-Sec-RHS-3

## KiCad design RHS_3.kicad_pcb

Parts:
BT1: Battery; CR2477_Surface_Mount
C1, C2, C3, C7: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC Part # C49678
C4, C5, C6: 10n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC Part # C1710
C8, C9, C10, C13: 10p; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC Part # C1785
C11, C12: 9p; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C14: 330µ; CP_Elec_6.3x5.8
C15: 4u7; C_0402_1005Metric
C16, C17, C18, C19, C20, C21, C22: 100n; C_0402_1005Metric
C23: 12p; C_0402_1005Metric
C24: 15p; C_0402_1005Metric
C25, C27, C28: 1p5; C_0402_1005Metric
C26: 1p; C_0402_1005Metric
C29: 3p3; C_0402_1005Metric
D1: LED Red; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC Part # C84256
D2: LED Green; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC Part # C2297
IC1: ATMEGA328P-A; TQFP-32_7x7mm_P0.8mm; LCSC Part # C14877
IC2: CC1101; CC1101_Module
IC3: CC1101_Chip; QFN-20-1EP_4x4mm_P0.5mm_EP2.5x2.5mm
J1: Glass Breakage Detector; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
J2: ANT; Pin_D1.0mm_L10.0mm
JP1, JP2: Jumper_NO_Small; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
L1, L2, L5, L6: 12nH; L_0402_1005Metric
L3, L4: 18nH; L_0402_1005Metric
P4: ISP Bottom; ISP_Side
P5: ISP Top; ISP_Side
P6: FTDI; PinHeader_1x06_P2.54mm_Vertical
P7: ISP 10; PinHeader_2x05_P2.54mm_Vertical
R1: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC Part # C17414
R2, R3: 1k5; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC Part # C4310
R4, R5, R6, R7: 1M; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC Part # C17514
R8: 56k; R_0402_1005Metric
SW1: Reset; MicroSwitch_3x4
SW2: Config; MicroSwitch_3x4
U1, U2, U3: TLE4913; SOT-23
X1: Resonator; Oscillator_SMD_EuroQuartz_XO32-4Pin_3.2x2.5mm
Y1: Crystal_Small; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
/A0: C9.1, IC1.23 ((PCINT8/ADC0)PC0), R5.2, U2.2 (Q)
/A1: C8.1, IC1.24 ((PCINT9/ADC1)PC1), R4.2, U1.2 (Q)
/A2: C10.1, IC1.25 ((PCINT10/ADC2)PC2), R6.2, U3.2 (Q)
/A3: C13.1, IC1.26 ((PCINT11/ADC3)PC3), J1.1, R7.2
/A4: IC1.27 ((PCINT12/SDA/ADC4)PC4)
/A5: IC1.28 ((PCINT13/SCL/ADC5)PC5)
/ANT: IC2.9 (ANT), J2.1, L6.2
/CS: IC1.14 ((PCINT2/OC1B/~SS~)PB2), IC2.8 (CSN), IC3.7 (CSn)
/D3: IC1.1 ((PCINT19/OC2B/INT1)PD3)
/D6: IC1.10 ((PCINT22/OC0A/AIN0)PD6); also elsewhere on the board
/D7: IC1.11 ((PCINT23/AIN1)PD7); also elsewhere on the board
/GDO0: IC1.32 ((PCINT18/INT0)PD2), IC2.7 (GDO0), IC3.6 (GDO0)
/MISO: IC1.16 ((PCINT4/MISO)PB4), IC2.5 (SO), IC3.2 (GDO1), P4.1, P7.9
/MOSI: IC1.15 ((PCINT3/OC2A/MOSI)PB3), IC2.3 (SI), IC3.20 (SI), P4.5, P7.1
/RESET: C7.2, IC1.29 ((PCINT14/~RESET~)PC6), P4.3, P7.5, R1.2, SW1.1
/RXD: IC1.30 ((PCINT16/RXD)PD0), P5.3, P6.3
/SCK: IC1.17 ((PCINT5/SCK)PB5), IC2.4 (SCLK), IC3.1 (SCLK), P4.2, P7.7
/TXD: IC1.31 ((PCINT17/TXD)PD1), P5.2, P6.2
/XTAL1: C11.1, IC1.7 ((PCINT6/XTAL1/TOSC1)PB6), Y1.1
/XTAL2: C12.1, IC1.8 ((PCINT7/XTAL2/TOSC2)PB7), Y1.2
GND: BT1.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.1, C27.2, C29.2, D1.1 (K), D2.1 (K), IC1.3 (GND), IC1.5 (GND), IC1.21 (GND), IC2.2 (GND), IC2.10 (GND), IC2.11 (GND), IC3.16 (GND), IC3.19 (GND), IC3.21 (GND), J1.2, P5.4, P5.5, P6.6, P7.8, P7.10, R8.1, SW1.2, SW2.2, U1.3 (GND), U2.3 (GND), U3.3 (GND), X1.2, X1.4
unnamed: C7.1, P6.1
unnamed: C22.1, IC3.5 (DCOUPL)
unnamed: C23.1, IC3.8 (XOSC_Q1), X1.1
unnamed: C24.1, IC3.10 (XOSC_Q2), X1.3
unnamed: C25.2, C26.1, L1.2, L4.1
unnamed: C26.2, C28.2, L2.2, L3.1
unnamed: C27.1, L3.2
unnamed: C28.1, L4.2, L5.1
unnamed: C29.1, L5.2, L6.1
unnamed: D1.2 (A), R2.1
unnamed: D2.2 (A), R3.1
unnamed: IC1.2 ((PCINT20/XCK/T0)PD4), R2.2
unnamed: IC1.9 ((PCINT21/OC0B/T1)PD5), R3.2
unnamed: IC3.12 (RF_P), L2.1
unnamed: IC3.13 (RF_N), L1.1
unnamed: IC3.17 (RBIAS), R8.2
VDD: C4.1, C5.1, C6.1, JP2.2, R4.1, R5.1, R6.1, R7.1, U1.1 (VS), U2.1 (VS), U3.1 (VS); also elsewhere on the board

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
Board: 2 copper layers, 51.0 x 61.0 mm, 68 parts (57 on the bottom side), 38 nets.

Other parts of the board:
Q1, Q2: Si2305CDS; SOT-23
R9, R10: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder

Their connections:
/D6: Q1.1, R9.2; also elsewhere on the board
/D7: Q2.1, R10.2; also elsewhere on the board
VDD: Q2.3; also elsewhere on the board

File gerber/BOM_RHS_3.csv:

Reference, Quantity, Value, Footprint, Datasheet, LCSC Part #, Reichelt
BT1 ,1,"Battery","libraries:CR2477_Surface_Mount",""
C1 C2 C3 C7 ,4,"100n","Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder","","C49678",""
C10 C9 C8 C13 ,4,"10p","Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder","","C1785",""
C11 C12 ,2,"9p","Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder",""
C14 ,1,"330µ","Capacitor_SMD:CP_Elec_6.3x5.8","~"
C15 ,1,"4u7","Capacitor_SMD:C_0402_1005Metric","~","C23733",""
C22 C27 C21 C20 C19 C18 C17 C16 ,8,"100n","Capacitor_SMD:C_0402_1005Metric","~","C1525",""
C23 ,1,"12p","Capacitor_SMD:C_0402_1005Metric","~","C1547",""
C24 ,1,"15p","Capacitor_SMD:C_0402_1005Metric","~","C1548",""
C25 C28 ,2,"1p5","Capacitor_SMD:C_0402_1005Metric","~","C1552",""
C26 ,1,"1p","Capacitor_SMD:C_0402_1005Metric","~","C1550",""
C29 ,1,"3p3","Capacitor_SMD:C_0402_1005Metric","~","C1565",""
C4 C5 C6 ,3,"10n","Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder","","C1710",""
D1 ,1,"LED Red","LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder","","C84256",""
D2 ,1,"LED Green","LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder","","C2297",""
IC1 ,1,"ATMEGA328P-A","Package_QFP:TQFP-32_7x7mm_P0.8mm","","C14877",""
IC2 ,1,"CC1101","libraries:CC1101_Module",""
IC3 ,1,"CC1101_Chip","Package_DFN_QFN:QFN-20-1EP_4x4mm_P0.5mm_EP2.5x2.5mm","","C29953",""
J1 ,1,"Glass Breakage Detector","Connector_JST:JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal","https://cdn-reichelt.de/documents/datenblatt/C100/JST_XH_DB_EN.pdf","","https://www.reichelt.de/jst-stiftleiste-gerade-1x2-polig-xh-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"
J2 ,1,"ANT","Connector_Pin:Pin_D1.0mm_L10.0mm","~"
JP1 JP2 ,2,"Jumper_NO_Small","Jumper:SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm","~"
L1 L2 L5 L6 ,4,"12nH","Inductor_SMD:L_0402_1005Metric","~","C24563",""
L3 L4 ,2,"18nH","Inductor_SMD:L_0402_1005Metric","~","C24562",""
P4 ,1,"ISP Bottom","libraries:ISP_Side",""
P5 ,1,"ISP Top","libraries:ISP_Side",""
P6 ,1,"FTDI","Connector_PinHeader_2.54mm:PinHeader_1x06_P2.54mm_Vertical","~"
P7 ,1,"ISP 10","Connector_PinHeader_2.54mm:PinHeader_2x05_P2.54mm_Vertical","~"
Q1 Q2 ,2,"Si2305CDS","Package_TO_SOT_SMD:SOT-23","","C37577",""
R1 R9 R10 ,3,"10k","Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder","","C17414",""
R2 R3 ,2,"1k5","Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder","","C4310",""
R4 R5 R6 R7 ,4,"1M","Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder","","C17514",""
R8 ,1,"56k","Resistor_SMD:R_0402_1005Metric","~","C25796",""
SW1 ,1,"Reset","libraries:MicroSwitch_3x4",""
SW2 ,1,"Config","libraries:MicroSwitch_3x4",""
U1 U2 U3 ,3,"TLE4913","Package_TO_SOT_SMD:SOT-23","","C126654",""
X1 ,1,"Resonator","Oscillator:Oscillator_SMD_EuroQuartz_XO32-4Pin_3.2x2.5mm","","C91747",""
Y1 ,1,"Crystal_Small","Crystal:Crystal_SMD_3215-2Pin_3.2x1.5mm","https://www.mouser.de/datasheet/2/137/C-255_en-1649561.pdf"

## Commit log

2020-04-01 initial checkin
2020-04-03 v1.1
2020-04-03 alternative pcb layout
2020-04-06 V1.1 ready
2020-04-08 use parameter from sheet
2020-04-08 small version layouted
2020-04-09 small layout updates - finish for first prototyp
2020-04-09 case small
2020-04-20 some small updates
2020-04-21 TLE pads resized
2020-04-22 allow to work as "normal" HM-Sec-RHS-2
2020-04-22 TLE-Pads resized again
2020-04-22 init sensor before channel
2020-04-22 case updates
2020-04-24 production files added
2020-05-03 support extra unlocked state when USE_FOUR_STATES is defined
2020-05-25 fix missing GND
2020-05-25 RHS-3 firmmware added
2020-06-08 fix missing GND areas
2020-06-19 new case variant
2020-06-19 use 1,6mm pcb height
2020-06-21 space for magnet holder fixed
2020-10-07 optional CC1101 direct use
2020-10-08 Jumper added to prepare switch of VCC for CC1101 und Sensors
2020-10-08 CC1101 footprint fixed
2020-10-09 layout changed
2020-10-09 part numbers added
2020-10-11 switches for TLEs & CC1101 added
2020-10-12 layout updates
2020-10-15 gerber and production files updated
2020-10-15 fix 100p
2021-02-12 Update HB-SEC-RHS-3.ino
    add ci comment
2021-02-12 make path compatible with Arduino IDE
2021-02-12 power pin
